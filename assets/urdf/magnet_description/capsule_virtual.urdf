Commit message: with rotation

File: assets/urdf/magnet_description/capsule_virtual.urdf (robot description, URDF)
Before this commit: robot capsule, 1 links, 0 joints
Links:
- link capsule_base: geometry visual mesh filename=meshes/capsule_virtual.stl scale=0.0005 0.0005 0.0005
